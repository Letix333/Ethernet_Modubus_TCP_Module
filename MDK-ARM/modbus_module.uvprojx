# Keil uVision project modbus_module.uvprojx, settings and files
target modbus_module (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: modbus_module +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\LwIP\system;..\LwIP\system\arch;..\LwIP\src\include;..\LwIP\src\include\ipv4;..\LwIP\src\include\lwip;..\LwIP\src\include\netif;..\LwIP\src\include\posix;..\LwIP\src\include\posix\sys;..\LwIP\src\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c app_ethernet.c enc28j60.c ethernetif.c main.c modbus_client.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_adc.c stm32f1xx_ll_dac.c stm32f1xx_ll_usart.c
    ./: stm32f1xx_hal_adc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group New Group
    ../LwIP/src/core/: def.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c dhcp.c
    ../LwIP/src/netif/: etharp.c ethernetif.c slipif.c
    ../LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
software components: CMSIS:CORE 5.3.0
